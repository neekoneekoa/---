# Keil uVision project LY_MLX90614.uvprojx, settings and files
target 红外测温 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LY_MLX90614
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\MLX90614;..\HARDWARE\OLED;.\HARDWARE;.\SYSTEM;.\HARDWARE\Timer;.\HARDWARE\HC05;.\HARDWARE\CountSensor;..\HARDWARE\Algorithm;..\HARDWARE\XIIC;..\HARDWARE\MAX30102;..\HARDWARE\XIIC;..\SYSTEM\usart3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../../红外 (1)原版/SYSTEM/usart/: usart.c
    ../SYSTEM/usart3/: usart3.c usart3.h
  group HARDWARE
    ../HARDWARE/MLX90614/: mlx90614.c mlx90614.h
    ../HARDWARE/OLED/: oled.c oled.h
    ./HARDWARE/: KEY.c KEY.h
    ./HARDWARE/CountSensor/: CountSensor.c CountSensor.h
    ./HARDWARE/HC05/: HC05.c HC05.h
    ../../红外 (1)原版/HARDWARE/Algorithm/: algorithm.c algorithm.h
    ../../红外 (1)原版/HARDWARE/MAX30102/: max30102.c max30102.h
    ../../红外 (1)原版/HARDWARE/XIIC/: blood.c xiic.c
